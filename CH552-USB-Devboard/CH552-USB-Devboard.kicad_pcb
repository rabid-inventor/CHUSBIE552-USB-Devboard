# Repository rabid-inventor/CHUSBIE552-USB-Devboard

## KiCad design CH552-USB-Devboard/CH552-USB-Devboard.kicad_pcb

Parts:
C1, C2: 100nF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C3, C5, C6: 100uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C4, C7: 1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1, D2, D3: LED; LED_0805
D4: SMCJ17A+; D_1812_4532Metric
J1, J2: Conn_01x11_Male; PinHeader_1x11_P2.54mm_Vertical
J3: USB_C_Receptacle; VACON_CSP_USC16_TR
JP1, JP2: Jumper; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
Q1: CPH6337; SOT-23-6
R3, R4: 330r; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R5: 300r; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
SW1, SW2: SW_Push; SW_SPST_PTS810
U1: CH552T; TSSOP-20_4.4x6.5mm_Pitch0.65mm
U2: CH552G; SOIC-16_3.9x9.9mm_Pitch1.27mm
U3: MIC5504-3.3YM5; SOT-23-5
Y1: Crystal; Crystal_SMD_HC49-SD

Connections:
+3V3: C2.1, C7.1, J1.3, SW1.1, U1.20 (V33), U2.16 (V33), U3.5 (VOUT)
/CC1: J3.A5, JP1.1
/CC2: J3.B5, JP2.1
/P1.0: J1.4, U1.7 (P1.0_T2_/_CAP1_/_TIN0_)
/P1.1: J1.5, U1.8 (P1.1/T2EX/CAP2/TIN1/VBUS2/AIN0), U2.9 (P1.1/T2EX/CAP2/TIN1/VBUS2/AIN0)
/P1.2: C5.1, J1.6, U1.17 (P1.2_XI_/_RXD_), Y1.1
/P1.3: C6.1, J1.7, U1.16 (P1.3_XO_/_TXD__), Y1.2
/P1.4: J1.8, JP1.2, U1.2 (P1.4/T2__/CAP1__/SCS/TIN2/UCC1/AIN1), U2.2 (P1.4/T2__/CAP1__/SCS/TIN2/UCC1/AIN1)
/P1.5: J1.9, JP2.2, U1.3 (P1.5/MOSI/PWM1/TIN3/UCC2/AIN2), U2.3 (P1.5/MOSI/PWM1/TIN3/UCC2/AIN2)
/P1.6: J1.10, U1.4 (P1.6/MISO/RXD1/TIN4), U2.4 (P1.6/MISO/RXD1/TIN4)
/P1.7: J1.11, U1.5 (P1.7/SCK/TXD1/TIN5), U2.5 (P1.7/SCK/TXD1/TIN5)
/P3.0: D1.2 (A), J2.4, U1.10 (P3.0/PWM1_/RXD), U2.8 (P3.0/PWM1_/RXD)
/P3.1: D2.2 (A), J2.5, U1.9 (P3.1/PWM2_/TXD), U2.7 (P3.1/PWM2_/TXD)
/P3.2: J2.6, U1.1 (P3.2_/TXD1__/INT0/VBUS/AIN3_1), U2.1 (P3.2_/TXD1__/INT0/VBUS/AIN3_1)
/P3.3: J2.7, U1.11 (P3.3/INT1), U2.10 (P3.3/INT1)
/P3.4: J2.8, U1.12 (P3.4/PWM2/RXD1/T0), U2.11 (P3.4/PWM2/RXD1/T0)
/P3.5: J2.9, U1.13 (P3.5_T1_)
/P3.6: J2.10, J3.A6, J3.B6, SW1.2, U1.14 (V3.6/UDP), U2.12 (V3.6/UDP)
/P3.7: J2.11, J3.A7, J3.B7, U1.15 (P3.7/UDM), U2.13 (P3.7/UDM)
/RESET: C3.2, J2.3, SW2.1, U1.6 (RST/T2EX_/CAP2_), U2.6 (RST/T2EX_/CAP2_)
GND: C1.2, C2.2, C4.2, C5.2, C6.2, C7.2, D3.1 (K), D4.2 (A), J2.1, J2.2, J3.1, J3.A1, J3.A12, J3.B1, J3.B12, J3.S1, R3.1, R4.1, U1.18 (GND/VSS), U2.14 (GND/VSS), U3.2 (GND)
unnamed: D1.1 (K), R3.2
unnamed: D2.1 (K), R4.2
unnamed: D3.2 (A), R5.2
VBUS: J1.1, J3.A4, J3.A9, J3.B4, J3.B9, Q1.1 (D), Q1.2 (D), Q1.5 (D), Q1.6 (D)
VCC: C1.1, C3.1, C4.1, D4.1 (K), J1.2, Q1.3 (G), Q1.4 (S), R5.1, SW2.2, U1.19 (VCC/VDD), U2.15 (VCC/VDD), U3.1 (VIN), U3.3 (EN)

Notes on the sheet:
POW
CH552T/G Development board
Bootloader select
Reset
Reverse Protection
Prevents Reverse powering of VBUS

Board: 2 copper layers, 22.0 x 40.5 mm, 26 parts (5 on the bottom side), 26 nets.

## Commit log

2020-04-11 first draft schmatic complete
2020-04-12 started on layout
2020-04-20 more schmatic work multilanding
2020-04-22 first route done
2020-04-22 ROUTING COMPLETE AND DRC DONE READY FOR SILK
2020-04-27 silks complete v1 ready
2020-05-07 tied bootloader switch to gnd not vcc and silk fixes
2020-05-21 checked and sent to porduction
2020-06-04 changed license to be permissive
2020-06-09 added stencil
2020-07-13 started updating schematic for version2
2020-07-19 routing started on v2
2020-07-20 update and created test grebers
2020-08-03 work on v2 silk
2020-08-04 silk complete and gerbe done ready to order
2021-10-11 added V2 BOM
